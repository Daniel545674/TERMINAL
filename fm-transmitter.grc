options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bb
  id: variable_qtgui_dial_control
  parameters:
    label: bb
    maximum: '100'
    minimum: '0'
    relBackgroundColor: purple
    showvalue: 'False'
    type: real
    value: '20'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '108000000'
  states: {}
- name: ifg
  id: variable_qtgui_dial_control
  parameters:
    label: if
    maximum: '100'
    minimum: '0'
    relBackgroundColor: purple
    showvalue: 'False'
    type: real
    value: '20'
  states: {}
- name: mic_gain
  id: variable_qtgui_dial_control
  parameters:
    maximum: '100'
    minimum: '0'
    relBackgroundColor: purple
    scaleFactor: '0.10'
    showvalue: 'False'
    type: real
    value: '50'
  states: {}
- name: music_gain
  id: variable_qtgui_dial_control
  parameters:
    label: music gain
    maximum: '10'
    minimum: '0'
    relBackgroundColor: white
    scaleFactor: '0.1'
    showvalue: 'True'
    type: real
    value: '0'
  states: {}
- name: rf
  id: variable_qtgui_dial_control
  parameters:
    label: rf
    maximum: '100'
    minimum: '0'
    relBackgroundColor: purple
    showvalue: 'False'
    type: real
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2000E3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1'
    max_dev: '75000'
    quad_rate: '441000'
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pulse
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: music_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mic_gain
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /media/psf/Home/Desktop/i7-930-MBR/Documents/Downloads/Sum 41 - A Death In The Family.mp3
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=000000000000000015a863dc224f8387
    bb_gain0: bb
    corr0: '6'
    freq0: center_freq
    gain0: rf
    if_gain0: ifg
    sample_rate: samp_rate * 2
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '11'
    interp: '100'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', analog_wfm_tx_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
